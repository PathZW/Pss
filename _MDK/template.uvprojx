# Keil uVision project template.uvprojx, settings and files
target LDBI016_SOUR (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Output +hex
  AfterMake: fromelf.exe --bin -o $PObjects\output.bin $PObjects\Output.axf
  AfterMake: cmd /c copy /Y "#H" "$P..\@L.hex" >nul
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: nEMB_LOG_LEVEL=LOG_LEVEL_WARN,  PRJ_LDBI,  LDBI_SOUR,  MCU_SENS
  c misc: --c99  --diag_suppress=4017    --preinclude=app_cfg.h  -DAPP_CFG=\"app_cfg.h\"  -D_RTE_
  c include: ../App/Port/Device/STM32F429ZGTx/;../App/;../App/Port/;../App/Port/CMSIS/;../App/Port/Compiler/;../App/Port/File_System/;../Bsp/;../Bsp/ARM_Compiler/Include/;../Bsp/CMSIS/Include/;../Bsp/CMSIS/Driver/Include/;../Bsp/CMSIS-Driver-Ext/Include/;../Bsp/CMSIS/RTOS2/Include/;../Bsp/CMSIS/RTOS2/RTX/Include/;../Bsp/STM32xx_Board/;../Bsp/STM32F4xx_StdPeriph_Device/Include/;../Bsp/STM32F4xx_StdPeriph_Driver/inc/;../Platform/;../Middlewares/;../Components/CmBacktrace/;../Components/easyflash/inc/;../Components/IniParser/;../Components/FileSystem/;../Components/FileSystem/Include/;../Components/Network/lwip_port/;../Components/Network/lwip_port/arch_CMSIS_RTOS2/include/;../Components/Network/lwip_port/netif_CMSIS/;../Components/Network/lwip/src/include/;../Components/Network/lwip/src/include/compat/stdc/;../Components/Network/lwip/src/include/compat/posix/;../Components/Micrium/uC-CONFIG/;../Components/Micrium/uC-BSP/;../Components/Micrium/uC-CPU/;../Components/Micrium/uC-CPU/ARM-Cortex-M/ARMv7-M/ARM/;../Components/Micrium/uC-LIB/;../Components/Micrium/uCOS-III/Ports/ARM-Cortex-M/ARMv7-M/ARM/;../Components/Micrium/uCOS-III/Source/
  asm misc: --cpreproc --cpreproc_opts=-DSystemInit="Platform_BareInit"
  memory RVCT4: ROM 0x8020000 size 0x60000
  memory RVCT5: ROM 0x8000000 size 0x4000
  memory RVCT8: RAM 0x40024000 size 0x1000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group App
    ../App/: app_cfg.h app_main.c App_mCal.c App_LDBI016.c Drv_LDBI016.c Drv_Board.c Drv_FpgaAds1259.c Drv_FpgaAd5683.c Drv_FpgaPwmTemp.c Drv_FpgaGpio.c Drv_FpgaComm.c Drv_FpgaPuls.c devDriver_FpgaAD4000.c devDriver_FpgaAD5761.c SMU_Source.c devDriver_FpgaAD1259.c devDriver_FpgaAD5683.c
  group App/Port
    ../App/Port/Device/STM32F429ZGTx/: main.h main.c stm32f4xx_it.c system_stm32f4xx.c startup_stm32f429xx.s RTE_Device.h
    ../App/Port/CMSIS/: RTX_Config.h
    ../App/Port/File_System/: FS_Config_NOR_0.h
    ../Components/Network/lwip_port/: lwipopts.h
  group Bsp/STM32xx_Board
    ../Bsp/STM32xx_Board/: Board_Device.h Board_Device.c Flash_STM32xx.c stdio_UART.c
    ../Bsp/CMSIS-Driver-STM32F4/: USART_STM32F4xx.c SPI_STM32F4xx.c EMAC_STM32F4xx.c stm32f4xx_hal_dma.c
    ../Bsp/CMSIS-Driver/ETH/: PHY_LAN8720.c
    ../Bsp/CMSIS-Driver-Ext/: PHY_DM8203EP.c
  group Bsp/STM32F4xx_LIB
    ../Bsp/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_rcc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_exti.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_fmpi2c.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_qspi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_lptim.c stm32f4xx_usart.c stm32f4xx_iwdg.c stm32f4xx_wwdg.c
    ../Bsp/STM32F4xx_StdPeriph_Device/Include/: stm32f4xx.h
  group Bsp/ARM_Compiler
    ../App/Port/Compiler/: EventRecorderConf.h
    ../Bsp/ARM_Compiler/Include/: EventRecorder.h
    ../Bsp/ARM_Compiler/Source/: EventRecorder.c retarget_io.c
  group Platform
    ../Platform/: defines.h emb_critical.h emb_delay.h emb_log.h emb_platform.h emb_platform.c emb_printk.h emb_printk.c emb_prompt.h emb_prompt.c emb_queue.h emb_repeat.h emb_rtcfg.h emb_rtcfg_ini.c emb_rtcfg_flash.c
  group Middlewares/cmd
    ../Middlewares/cmd/: Cmd_App.h Cmd_App.c Cmd_RS232.h Cmd_RS232.c Cmd_RS485.h Cmd_RS485.c Cmd_UART1.h Cmd_UART1.c Cmd_UART2.h Cmd_UART2.c Cmd_SPIx.h Cmd_SPIx.c Cmd_SPIy.h Cmd_SPIy.c Cmd_TCP.h Cmd_TCP.c
  group Middlewares/ver
    ../Middlewares/ver/: version.h version.c
  group Middlewares/shell
    ../Middlewares/shell/: cli_shell.h cli_shell.c cli_shell_priv.h
  group Components/CmBacktrace
    ../Components/CmBacktrace/: assert.h cm_backtrace.h cm_backtrace.c cmb_cfg.h
  group Components/EasyFlash
    ../Components/easyflash/inc/: easyflash.h ef_cfg.h
    ../Components/easyflash/src/: easyflash.c ef_env.c ef_iap.c ef_log.c ef_utils.c
    ../Components/easyflash/port/: ef_port.c
  group Components/IniParser
    ../Components/IniParser/: iniparser.h iniparser.c dictionary.h dictionary.c
  group Components/FileSystem
    ../Components/FileSystem/: fs_user.h fs_user.c
    ../Components/FileSystem/Include/: rl_fs.h
    ../App/Port/File_System/: FS_Config.c FS_Config_NOR_0.h
    ../Components/FileSystem/Lib/ARM/: FS_LFN_CM3_L.lib
  group Components/Network
    ../Components/Network/lwip/src/apps/: 
    ../Components/Network/lwip/src/api/:  api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../Components/Network/lwip/src/core/:  altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../Components/Network/lwip/src/core/ipv4/:  autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../Components/Network/lwip/src/core/ipv6/:  dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
    ../Components/Network/lwip/src/netif/:  ethernet.c
    ../Components/Network/lwip_port/:  net_user.h net_user.c net_device.c lwipopts.h
    ../Components/Network/lwip_port/netif_CMSIS/: netdev_eth.c
    ../Components/Network/lwip_port/arch_CMSIS_RTOS2/: sys_arch.c
  group CMSIS-RTOS2 : RTX
    ../Bsp/CMSIS/RTOS2/Include/: cmsis_os2.h
    ../Bsp/CMSIS/RTOS2/RTX/Source/: rtx_delay.c rtx_evflags.c rtx_evr.c rtx_kernel.c rtx_memory.c rtx_mempool.c rtx_msgqueue.c rtx_mutex.c rtx_semaphore.c rtx_system.c rtx_thread.c rtx_timer.c rtx_lib.c
    ../Bsp/CMSIS/RTOS2/RTX/Source/ARM/: irq_cm4f.s
    ../Bsp/CMSIS/RTOS2/Source/: os_systick.c
    ../App/Port/CMSIS/: RTX_Config.c RTX_Config.h
  group CMSIS-RTOS2 : uCOS-III
    ../Components/Micrium/: ---- uC-CONFIG ---- ---- uCOS-III :: Source ---- ---- uCOS-III :: TLS ---- ---- uCOS-III :: Ports ---- ---- uC-CPU ---- ---- uC-BSP ----
    ../Components/Micrium/uC-CONFIG/: os_cfg.h os_cfg_app.h cpu_cfg.h
    ../Components/Micrium/CMSIS/RTOS2/uCOS-III/Source/: cmsis_os2.c
    ../Components/Micrium/uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_mem.c os_msg.c os_mutex.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
    ../Components/Micrium/uCOS-III/TLS/ARM/: os_tls.c
    ../Components/Micrium/uCOS-III/Ports/ARM-Cortex-M/ARMv7-M/ARM/: os_cpu.h os_cpu_a.asm
    ../Components/Micrium/uCOS-III/Ports/ARM-Cortex-M/ARMv7-M/: os_cpu_c.c
    ../Components/Micrium/uC-CPU/ARM-Cortex-M/ARMv7-M/ARM/: cpu.h cpu_a.asm
    ../Components/Micrium/uC-CPU/ARM-Cortex-M/ARMv7-M/: cpu_c.c
    ../Components/Micrium/uC-CPU/: cpu_core.h cpu_core.c
    ../Components/Micrium/uC-BSP/: bsp_int.h bsp_int_armv7m.c bsp_cpu_armv7m.c bsp_os_armv7m.c
target LDBI016_SENS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: as above
  output: Output +hex
  AfterMake: as above
  AfterMake: cmd /c copy /Y "#H" "$P..\@L.hex" >nul
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: nEMB_LOG_LEVEL=LOG_LEVEL_WARN,  PRJ_LDBI,  LDBI_SENS,  MCU_SOUR
  c misc: as above
  c include: ../App/Port/Device/STM32F429ZGTx/;../App/;../App/Port/;../App/Port/CMSIS/;../App/Port/Compiler/;../App/Port/File_System/;../Bsp/;../Bsp/ARM_Compiler/Include/;../Bsp/CMSIS/Include/;../Bsp/CMSIS/Driver/Include/;../Bsp/CMSIS-Driver-Ext/Include/;../Bsp/CMSIS/RTOS2/Include/;../Bsp/CMSIS/RTOS2/RTX/Include/;../Bsp/STM32xx_Board/;../Bsp/STM32F4xx_StdPeriph_Device/Include/;../Bsp/STM32F4xx_StdPeriph_Driver/inc/;../Platform/;../Middlewares/;../Components/CmBacktrace/;../Components/easyflash/inc/;../Components/IniParser/;../Components/FileSystem/;../Components/FileSystem/Include/;../Components/Network/lwip_port/;../Components/Network/lwip_port/arch_CMSIS_RTOS2/include/;../Components/Network/lwip_port/netif_CMSIS/;../Components/Network/lwip/src/include/;../Components/Network/lwip/src/include/compat/stdc/;../Components/Network/lwip/src/include/compat/posix/;../Components/Micrium/uC-CONFIG/;../Components/Micrium/uC-BSP/;../Components/Micrium/uC-CPU/;../Components/Micrium/uC-CPU/ARM-Cortex-M/ARMv7-M/ARM/;../Components/Micrium/uC-LIB/;../Components/Micrium/uCOS-III/Ports/ARM-Cortex-M/ARMv7-M/ARM/;../Components/Micrium/uCOS-III/Source/;..\App
  asm misc: --cpreproc --cpreproc_opts=-DSystemInit="Platform_BareInit"
  memory RVCT4: ROM 0x8020000 size 0x60000
  memory RVCT5: ROM 0x8000000 size 0x4000
  memory RVCT8: RAM 0x40024000 size 0x1000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
